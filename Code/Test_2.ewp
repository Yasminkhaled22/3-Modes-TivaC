# IAR project Test_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.0\inc; F:\F_Downloads\LCD_Files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.0\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: bitwise.h Buzzer.c Buzzer.h Calculator.c Calculator.h cpu.c cpu.h debug.h Delay.c Delay.h DIO.c DIO.h gpio.c gpio.h hw_flash.h hw_ints.h hw_memmap.h hw_nvic.h hw_sysctl.h hw_types.h interrupt.c interrupt.h keypad.c keypad.h lcd.c lcd.h main_.c startup_ewarm.c Stop_watch.c Stop_watch.h Switch_Button.c Switch_Button.h sysctl.c sysctl.h Timer0.c Timer0.h Timer1.c Timer1.h Timer_Mode.c Timer_Mode.h tm4c123gh6pm_startup_ccs.c types.h
